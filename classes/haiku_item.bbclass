# This Items are built from Haiku common source tree
S = "${TMPDIR}/work-shared/${PN}-${PV}-${PR}/"
